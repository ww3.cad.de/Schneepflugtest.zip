# Autodesk Inventor part: Bauteil1
## iProperties
Created: 2008-12
Part Number: Bauteil1
Document SubType Name: Modeling
Designer: Hans-Jürgen Eicke
Author: Hans-Jürgen Eicke
